# Keil uVision project main.uvproj, settings and files
target GPIO_INT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: main
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\Device\Nuvoton\M051Series\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\Library\ProjectSpecific\inc
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: main.c
  group Library
    ../Library/StdDriver/src/: clk.c fmc.c gpio.c sys.c timer.c uart.c wdt.c
  group External
    ../Library/ProjectSpecific/src/: keypad.c lcd4bit.c QuectelMC60.c
